# Keil uVision project tos_demo.uvprojx, settings and files
target stm32f103 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_exam +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\code\app;.\code\bsp;.\code\bsp\stm32f1;.\code\bsp\stm32f1\CMSIS\CM3\CoreSupport;.\code\srv\shell;.\code\srv\log;.\code\util;.\code\tos\core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./code/app/: main.c
  group bsp
    ./code/bsp/: bsp.c
    ./code/bsp/stm32f1/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./code/bsp/stm32f1/: STM32F10x.s
  group srv
    code/srv/log/: log_core.c
    code/srv/shell/: shell_cfg.c shell_core.c
  group tos
    code/tos/core/: tos_core.c tos_cond.c tos_mutex.c
    code/tos/ports/stm32f1/: tos_cpu_c.c tos_cpu_s.s
  group util
    code/util/: util_fifo_buffer.c util_time.c
